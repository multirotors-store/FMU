## src/drivers/bms_smbus/Kconfig
```kconfig
menuconfig DRIVERS_BMS_SMBUS
	bool "bms_smbus"
	default y
	---help---
		Enable support for bms_smbus
```
